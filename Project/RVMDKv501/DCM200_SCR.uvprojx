# Keil uVision project DCM200_SCR.uvprojx, settings and files
target DCM200_SCR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZGP331_SCR_E_V531-20250221 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\output\ZGP331_App.bin .\output\ZGP331_SCR_E_V531-20250221.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,SEMIHOSTING,PLATFORM=SX12xxEiger
  c include: ..\..\Libraries\inc;..\..\User;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\SysTick;..\..\User\SX1278;..\..\User\SX1278\radio;..\..\User\SX1278\platform\bleeper;..\..\User\SX1278\platform\sx1200dvk;..\..\User\SX1278\platform\sx1243ska;..\..\User\SX1278\platform\sx12xxEiger;..\..\User\SX1278\platform;..\..\User\iap
  library: MicroLIB
  memory RVCT4: ROM 0x8006800 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../../Libraries/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_dma.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group User
    ../../User/: main.c DoWith.c com1_232.c com2_232.c com3_232.c com4_232.c stm32f10x_it.c spi_flash.c com_LoRa.c Gprs_at.c Key_Menu.c LCD.c LcdGraphic.C xmodem.c malloc.c xmodem_1.c
  group radio
    ../../User/SX1278/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group sx12xxEiger
    ../../User/SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c
  group iap
    ../../User/iap/: iap.c iap_interface.c cString.c
